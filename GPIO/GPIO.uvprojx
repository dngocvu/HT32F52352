# Keil uVision project GPIO.uvprojx, settings and files
target HT32F52 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.10
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1fe00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32F52342_52
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./: main.c ht32f5xxxx_01.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 1.0.1
